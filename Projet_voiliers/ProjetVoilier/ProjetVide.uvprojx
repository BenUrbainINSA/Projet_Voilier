# Keil uVision project ProjetVide.uvprojx, settings and files
target Reel (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Projet3FISA
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: ..\..\My_Drivers\Include;.\Service\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Application/: principal.c
  group Drivers
    ../../My_Drivers/Source/: Driver_GPIO.c MyEncoder.c MyTimer.c MyUSART.c
  group Services
    ./Service/Source/: ModulePlateau.c
target Simulation (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: ProjetVide
  c flags: Optim=1 OneElfS=1 v6LangP=3 wLevel=2
  c include: ..\..\My_Drivers\Include;.\Service\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
